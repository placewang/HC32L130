# Keil uVision project E723.uvprojx, settings and files
target DEBUG (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: E723 +hex
  AfterMake: E:\kail\ARM\ARMCC\bin\fromelf.exe  --bin  -o./HEX/E723.bin ./HEX/E723.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\driver\inc;..\mcu\common;..\user\In
  memory RVCT4: ROM 0x2c00 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Source Group 1
    ../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
    ./: startup_hc32l13x.s
  group bsp
    ../user/: bsp_gpio.c bsp_clk.c bsp_time.c bsp_uart.c bsp_flash.c bsp_touch.c
  group user
    ../user/: queue.c crc16.c
  group lib
    ../driver/src/: sysctrl.c ddl.c gpio.c flash.c bt.c uart.c lpuart.c lpm.c spi.c wdt.c
  group app
    ../user/: app_key.c app_Version.c app_Cmd.c app_uart0.c app.lpuart.c app_gpsuart0.c app_gprsCmd.c
  group main
    ../main/: main.c
target RELEASE (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: as above
  output: E723 +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\driver\inc;..\mcu\common;..\user\In
  asm define: NDEBUG
  memory RVCT4: ROM 0x2c00 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
